# Keil uVision project Project1.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\Startup;.\User;.\Hardware\led;.\Basic\sys;.\Basic\delay;.\Hardware\key;.\Basic\flash;.\Hardware\buzzer;.\Basic\usart;.\Basic\rtc;.\Hardware\touch_key;.\Basic\TM1640;.\Hardware\encooder;.\Basic\i2c;.\Hardware\lm75a;.\Hardware\oled
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group User
    ./User/: main.c stm32f10x_it.c
  group Hardware
    ./Hardware/led/: led.c
    ./Hardware/key/: key.c
    ./Hardware/buzzer/: buzzer.c
    ./Hardware/touch_key/: touch_key.c
    ./Hardware/encooder/: encooder.c
    ./Hardware/lm75a/: lm75a.c
    ./Hardware/oled/: oled.c
  group Basic
    ./Basic/sys/: sys.c
    ./Basic/delay/: delay.c
    ./Basic/flash/: flash.c
    ./Basic/usart/: usart.c
    ./Basic/rtc/: rtc.c
    ./Basic/TM1640/: TM1640.c
    ./Basic/i2c/: i2c.c
